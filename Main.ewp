# IAR project Main.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: code\main; code\led; code\key; code\timer; code\adc; code\oled; code\utils; code\uart; code\oled\Font; code\oled\HAL_LCD_SPI; code\oled\HAL_LCD_SPI\SPI_Driver; code\oled\HAL_OLED
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group adc
    code/adc/: adc.c adc.h hal_adc.c hal_adc.h
  group key
    code/key/: key.c key.h
  group led
    code/led/: led.c led.h
  group Main
    code/main/: main.c main.h
  group oled
    code/oled/: oled.c oled.h
  group oled/Font
    code/oled/Font/: font_chinese_h_16x16.h font_chinese_v_16x16.h font_h_8x16.h font_rgb_picture.h font_v_8x16.h font_v_picture.h
  group oled/hal_oled12864
    code/oled/HAL_OLED/: hal_oled12864.c hal_oled12864.h
  group oled/LCE_SPI
    code/oled/HAL_LCD_SPI/: hal_lcd_spi.c hal_lcd_spi.h
  group oled/LCE_SPI/spi_Driver
    code/oled/HAL_LCD_SPI/SPI_Driver/: hw_spi.c hw_spi.h spi_common.h sw_spi.c sw_spi.h
  group timer
    code/timer/: timer.c timer.h
  group uart
    code/uart/: uart.c uart.h
  group utils
    code/utils/: utils.c utils.h
